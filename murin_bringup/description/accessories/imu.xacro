Commit message: i

File: murin_bringup/description/accessories/imu.xacro (robot description, xacro)
@@ -20,5 +20,5 @@
         <parent link="base_link"/>
         <child link="imu_link"/>
-        <origin xyz="0 0 0.01"/>
+        <origin xyz="0.105 -0.035 0.035"/>
     </joint>
     <!--  -->
